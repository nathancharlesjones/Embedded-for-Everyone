# Keil uVision project CM33_s.uvprojx, settings and files
target FVP Simulation Model (6100001::V6.10.1::.\ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.3.1-dev7
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: CM33_s
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Objects\CM33_s.sct
  group Secure Code
    ./: Abstract.txt main_s.c Hardfault.c IncidentLog_s.c SysTick_s.c
  group Interface
    ./: tz_context.c interface.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.1.0
