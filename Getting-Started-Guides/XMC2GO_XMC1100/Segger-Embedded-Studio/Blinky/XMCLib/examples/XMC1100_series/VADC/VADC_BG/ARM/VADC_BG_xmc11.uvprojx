# Keil uVision project VADC_BG_xmc11.uvprojx, settings and files
target VADC_BG_xmc11 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC1100-T038x0064 Infineon
  pack: Infineon.XMC1000_DFP.2.9.0
  cpu: IROM(0x10001000,0x10000) IRAM(0x20000000,0x3FFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: VADC_BG_xmc11
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x10001000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group Source
    ../: main.c
  group Doc
    ../: Readme.txt
software components: CMSIS:CORE 5.2.0, Device:Startup 2.1.0, Device:XMClib:SCU 2.1.18, Device:XMClib:VADC 2.1.18
