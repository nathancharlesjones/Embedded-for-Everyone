# Keil uVision project eru_rtc_xtal1_io_xmc44.uvprojx, settings and files
target eru_rtc_xtal1_io_xmc44 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4400-F100x512 Infineon
  pack: Infineon.XMC4000_DFP.2.11.0
  cpu: IRAM(0x20000000,0xFFC0) IRAM2(0x1FFFC000,0x4000) IROM(0x08000000,0x80000) IROM2(0x0C000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: eru_rtc_xtal1_io_xmc44
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  group Source
    ../: main.c
  group Doc
    ../: Readme.txt
software components: CMSIS:CORE 5.2.0, Device:Startup 2.2.0, Device:XMClib:ERU 2.1.18, Device:XMClib:GPIO 2.1.18, Device:XMClib:SCU 2.1.18
