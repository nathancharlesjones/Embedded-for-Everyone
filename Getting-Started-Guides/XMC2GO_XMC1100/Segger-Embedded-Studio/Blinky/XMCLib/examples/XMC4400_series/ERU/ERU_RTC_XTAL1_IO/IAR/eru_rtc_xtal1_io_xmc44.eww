<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\eru_rtc_xtal1_io_xmc44.ewp</path>
  </project>
  <batchBuild/>
</workspace>


