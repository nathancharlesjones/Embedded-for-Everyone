# Keil uVision project scu_hib_xmc42.uvprojx, settings and files
target scu_hib_xmc42 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4200-Q48x256 Infineon
  pack: Infineon.XMC4000_DFP.2.13.0
  cpu: IRAM(0x20000000,0x5FC0) IRAM2(0x1FFFC000,0x4000) IROM(0x08000000,0x40000) IROM2(0x0C000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: scu_hib_xmc42
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0xc000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5fc0
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  group Source
    ../: main.c
  group Doc
    ../: Readme.txt
software components: CMSIS:CORE 5.3.0, Device:Startup 2.2.4, Device:XMClib:GPIO 2.1.24, Device:XMClib:RTC 2.1.24, Device:XMClib:SCU 2.1.24
