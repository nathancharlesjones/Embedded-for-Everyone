<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TSE_CALC_TEMPERATURE_XMC14.ewp</path>
  </project>
  <batchBuild/>
</workspace>


