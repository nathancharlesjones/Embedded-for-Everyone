# Keil uVision project TSE_CALC_TEMPERATURE_XMC14.uvprojx, settings and files
target TSE_CALC_TEMPERATURE_XMC14 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC1402-F064x0200 Infineon
  pack: Infineon.XMC1000_DFP.2.9.0
  cpu: IRAM(0x20000000,0x3FFC) IROM(0x10001000,0x32000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TSE_CALC_TEMPERATURE
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x10001000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group Source Files
    ../: main.c retarget_io.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.0.0, Device:XMClib:GPIO 2.1.8, Device:XMClib:SCU 2.1.8, Device:XMClib:UART 2.1.8, Compiler:I/O:STDOUT 1.2.0
