# Keil uVision project i2c_eeprom_xmc14.uvprojx, settings and files
target i2c_eeprom_xmc14 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC1404-Q064x0200 Infineon
  pack: Infineon.XMC1000_DFP.2.9.0
  cpu: IRAM(0x20000000,0x3FFC) IROM(0x10001000,0x32000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: blinky
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\i2c_eeprom;..\..\..\..\..\..\ThirdPartyLibraries\FreeRTOS\Source\include;..\..\..\..\..\..\ThirdPartyLibraries\FreeRTOS\Source\portable\RVDS\ARM_CM0
  memory RVCT4: ROM 0x10001000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group Source Files
    ../: main.c eeprom.c
  group Documentation
    ../: Readme.txt
software components: CMSIS:CORE 5.2.0, Device:Startup 2.1.0, Device:XMClib:GPIO 2.1.18, Device:XMClib:I2C 2.1.18, Device:XMClib:SCU 2.1.18
