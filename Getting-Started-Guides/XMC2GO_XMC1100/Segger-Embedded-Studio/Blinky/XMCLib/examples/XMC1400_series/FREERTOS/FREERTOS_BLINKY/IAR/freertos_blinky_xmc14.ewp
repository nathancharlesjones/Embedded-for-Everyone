# IAR project freertos_blinky_xmc14.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: XMC1404-Q064x0200 Infineon XMC1404-Q064x0200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: XMC1404_Q064x0200
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\..\..\XMCLib\inc; ..\..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\..\CMSIS\Infineon\XMC1400_series\Include; ..\..\..\..\..\..\ThirdPartyLibraries\FreeRTOS\Source\include; ..\..\..\..\..\..\ThirdPartyLibraries\FreeRTOS\Source\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\..\CMSIS\Infineon\XMC1400_series\Include; ..
  OBJCOPY.OOCOutputFile: freertos_blinky_xmc14.srec
  ILINK.IlinkOutputFile: freertos_blinky_xmc14.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group FreeRTOS
    ../../../../../../ThirdPartyLibraries/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../ThirdPartyLibraries/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../ThirdPartyLibraries/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group Libraries/CMSIS
    ../../../../../../CMSIS/Infineon/XMC1400_series/Source/IAR/: startup_XMC1400.s
    ../../../../../../CMSIS/Infineon/XMC1400_series/Source/: system_XMC1400.c
  group Libraries/XMCLib
    ../../../../../src/: xmc1_eru.c xmc1_flash.c xmc1_gpio.c xmc1_rtc.c xmc1_scu.c xmc_can.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_dac.c xmc_dma.c xmc_dsd.c xmc_ebu.c xmc_eru.c xmc_eth_mac.c xmc_fce.c xmc_gpio.c xmc_i2c.c xmc_i2s.c xmc_posif.c xmc_rtc.c xmc_sdmmc.c xmc_spi.c xmc_uart.c xmc_usbd.c xmc_usic.c xmc_vadc.c xmc_wdt.c
