# Keil uVision project can_loopback_ext_osc_xmc14.uvprojx, settings and files
target can_loopback_ext_osc_xmc14 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC1404-F064x0064 Infineon
  pack: Infineon.XMC1000_DFP.2.9.0
  cpu: IROM(0x10001000,0x10000) IRAM(0x20000000,0x3FFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: can_loopback_ext_osc
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x10001000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group Source Group 1
    ../: main.c
software components: CMSIS:CORE 4.2.0, Device:Startup 1.3.0, Device:XMClib:CAN 2.1.0, Device:XMClib:GPIO 2.1.0, Device:XMClib:SCU 2.1.0
