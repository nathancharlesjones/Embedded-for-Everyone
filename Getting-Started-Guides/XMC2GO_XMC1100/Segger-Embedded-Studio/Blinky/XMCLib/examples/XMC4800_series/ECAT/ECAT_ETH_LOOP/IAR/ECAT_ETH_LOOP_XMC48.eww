<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ECAT_ETH_LOOP_XMC48.ewp</path>
  </project>
  <batchBuild/>
</workspace>


