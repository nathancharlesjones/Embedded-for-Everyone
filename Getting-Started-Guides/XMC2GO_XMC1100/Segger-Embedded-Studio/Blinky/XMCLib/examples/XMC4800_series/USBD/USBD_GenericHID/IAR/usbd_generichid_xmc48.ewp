# IAR project usbd_generichid_xmc48.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: XMC4800-F144x2048 Infineon XMC4800-F144x2048
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: XMC4800_F144x2048
  ICCARM.CCIncludePath2: ..\.; ..\..\..\..\..\inc; ..\..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\..\CMSIS\Infineon\XMC4800_series\Include; ..\..\..\..\..\..\ThirdPartyLibraries\USBlib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: usbd_generichid_xmc48.out
  ILINK.IlinkIcfFile: ..\XMC4800xxxxx2048.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: Descriptors.c GenericHID.c main.c
  group Libraries/CMSIS
    ../../../../../../CMSIS/Infineon/XMC4800_series/Source/IAR/: startup_XMC4800.s
    ../../../../../../CMSIS/Infineon/XMC4800_series/Source/: system_XMC4800.c
  group Libraries/USB
    ../../../../../../ThirdPartyLibraries/USBlib/USB/Core/: ConfigDescriptors.c Events.c USBTask.c
    ../../../../../../ThirdPartyLibraries/USBlib/USB/Core/XMC4000/: Endpoint_XMC4000.c EndpointStream_XMC4000.c USBController_XMC4000.c
    ../../../../../../ThirdPartyLibraries/USBlib/USB/Class/Device/: HIDClassDevice.c
  group Libraries/XMClib
    ../../../../../src/: xmc4_gpio.c xmc4_scu.c xmc_common.c xmc_gpio.c xmc_usbd.c
