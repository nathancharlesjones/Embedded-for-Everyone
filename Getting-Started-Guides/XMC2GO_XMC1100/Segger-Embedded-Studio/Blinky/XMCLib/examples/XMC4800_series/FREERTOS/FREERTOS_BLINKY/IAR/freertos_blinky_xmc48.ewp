# IAR project freertos_blinky_xmc48.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: XMC4800-F144x2048 Infineon XMC4800-F144x2048
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: XMC4800_F144x2048
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\..\..\XMCLib\inc; ..\..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\..\CMSIS\Infineon\XMC4800_series\Include; ..\..\..\..\..\..\ThirdPartyLibraries\FreeRTOS\Source\include; ..\..\..\..\..\..\ThirdPartyLibraries\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: XMC4800_F144x2048
  AARM.AUserIncludes: ..\..\..\..\..\..\XMCLib\inc; ..\..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\..\CMSIS\Infineon\XMC4800_series\Include; ..
  OBJCOPY.OOCOutputFile: freertos_blinky_xmc48.srec
  ILINK.IlinkOutputFile: freertos_blinky_xmc48.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group FreeRTOS
    ../../../../../../ThirdPartyLibraries/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../ThirdPartyLibraries/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../ThirdPartyLibraries/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Libraries/CMSIS
    ../../../../../../CMSIS/Infineon/XMC4800_series/Source/IAR/: startup_XMC4800.s
    ../../../../../../CMSIS/Infineon/XMC4800_series/Source/: system_XMC4800.c
  group Libraries/XMClib
    ../../../../../src/: xmc4_eru.c xmc4_flash.c xmc4_gpio.c xmc4_rtc.c xmc4_scu.c xmc_can.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_dac.c xmc_dma.c xmc_ebu.c xmc_ecat.c xmc_eru.c xmc_eth_mac.c xmc_eth_phy_dp83848.c xmc_eth_phy_ksz8031rnl.c xmc_eth_phy_ksz8081rnb.c xmc_fce.c xmc_gpio.c xmc_hrpwm.c xmc_i2c.c xmc_ledts.c xmc_posif.c xmc_rtc.c xmc_sdmmc.c xmc_spi.c xmc_uart.c xmc_usbd.c xmc_usic.c xmc_vadc.c xmc_wdt.c
