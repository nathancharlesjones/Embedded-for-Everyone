# Keil uVision project wdt_prewarning_xmc48.uvprojx, settings and files
target wdt_prewarning_xmc48 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4800-F144x1536 Infineon
  pack: Infineon.XMC4000_DFP.2.13.0
  cpu: IROM(0x08000000,0x180000) IROM2(0x0C000000,0x180000) IRAM(0x20000000,0x2CFC0) IRAM2(0x1FFE8000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wdt_prewarning_xmc48
  c flags: Optim=1 uC99=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT5: ROM 0xc000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x2cfc0
  memory RVCT10: RAM 0x1ffe8000 size 0x18000
  group Source
    ../: main.c
  group Doc
    ../: Readme.txt
software components: CMSIS:CORE 5.2.0, Device:Startup 2.2.0, Device:XMClib:GPIO 2.1.18, Device:XMClib:SCU 2.1.18, Device:XMClib:WDT 2.1.18
