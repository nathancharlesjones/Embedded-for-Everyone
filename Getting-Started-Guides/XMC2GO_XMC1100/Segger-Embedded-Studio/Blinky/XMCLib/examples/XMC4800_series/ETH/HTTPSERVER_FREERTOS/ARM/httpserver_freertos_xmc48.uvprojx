# Keil uVision project httpserver_freertos_xmc48.uvprojx, settings and files
target httpserver_freertos_xmc48 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4800-F144x2048 Infineon
  pack: Infineon.XMC4000_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x0C000000,0x100000) IRAM(0x20000000,0xFFC0) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: httpserver_freertos_xmc48
  c flags: Optim=2 uC99=1 wLevel=2
  c define: XMC_ETH_PHY_KSZ8081RNB
  c include: ..;..\..\..\..\..\..\ThirdPartyLibraries\FreeRTOS\Source\include;..\..\..\..\..\..\ThirdPartyLibraries\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\ThirdPartyLibraries\lwip\src\include;..\..\..\..\..\..\ThirdPartyLibraries\lwip\src\include\ipv4;..\..\..\..\..\..\ThirdPartyLibraries\lwip\src\port\freertos\include;..\..\..\..\..\..\ThirdPartyLibraries\lwip\src\port\freertos\netif
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x3ffc0
  memory RVCT10: RAM 0x1ffe8000 size 0x18000
  group Source
    ../: main.c ethernetif_init.c retarget_io.c ring_buffer.c serial.c FreeRTOSConfig.h lwipopts.h
    ../../../../../../ThirdPartyLibraries/lwip/src/apps/http/: altcp_proxyconnect.c fs.c http_client.c httpd.c
  group Doc
    ../: README.txt
  group FreeRTOS
    ../../../../../../ThirdPartyLibraries/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../ThirdPartyLibraries/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../ThirdPartyLibraries/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group lwip
    ../../../../../../ThirdPartyLibraries/lwip/src/netif/: ethernet.c lowpan6.c
    ../../../../../../ThirdPartyLibraries/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../../../../../../ThirdPartyLibraries/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
    ../../../../../../ThirdPartyLibraries/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../ThirdPartyLibraries/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../ThirdPartyLibraries/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../../ThirdPartyLibraries/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../../ThirdPartyLibraries/lwip/src/port/freertos/: sys_arch.c
    ../../../../../../ThirdPartyLibraries/lwip/src/port/freertos/netif/: ethernetif.c
software components: CMSIS:CORE 5.2.0, Device:Startup 2.2.0, Device:XMClib:ETH_MAC 2.1.18, Device:XMClib:ETH_PHY 2.1.18, Device:XMClib:GPIO 2.1.18, Device:XMClib:SCU 2.1.18, Device:XMClib:UART 2.1.18, Compiler:I/O:STDOUT 1.2.0
