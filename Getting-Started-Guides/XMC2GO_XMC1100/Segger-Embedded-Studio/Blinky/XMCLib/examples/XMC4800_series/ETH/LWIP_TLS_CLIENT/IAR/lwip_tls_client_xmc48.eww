<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lwip_tls_client_xmc48.ewp</path>
  </project>
  <batchBuild/>
</workspace>


