<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DAC_SINE_XMC48.ewp</path>
  </project>
  <batchBuild/>
</workspace>


