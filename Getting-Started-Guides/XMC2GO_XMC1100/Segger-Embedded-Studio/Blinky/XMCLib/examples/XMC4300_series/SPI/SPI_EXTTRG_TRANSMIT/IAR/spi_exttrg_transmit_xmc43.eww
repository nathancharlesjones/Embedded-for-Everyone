<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\spi_exttrg_transmit_xmc43.ewp</path>
  </project>
  <batchBuild/>
</workspace>


