# IAR project vadc_measurement_xmc12.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: XMC1200-T038x0200 Infineon XMC1200-T038x0200
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: XMC1200_T038x0200
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\XMClib\inc; ..\..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\..\CMSIS\Infineon\XMC1200_series\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: vadc_measurement_xmc12.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group Libraries/CMSIS
    ../../../../../../CMSIS/Infineon/XMC1200_series/Source/IAR/: startup_XMC1200.s
    ../../../../../../CMSIS/Infineon/XMC1200_series/Source/: system_XMC1200.c
  group Libraries/XMClib
    ../../../../../src/: xmc1_eru.c xmc1_flash.c xmc1_gpio.c xmc1_rtc.c xmc1_scu.c xmc_acmp.c xmc_bccu.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_eru.c xmc_gpio.c xmc_i2c.c xmc_ledts.c xmc_math.c xmc_posif.c xmc_prng.c xmc_rtc.c xmc_spi.c xmc_uart.c xmc_usic.c xmc_vadc.c xmc_wdt.c
