<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ledts_example2_xmc12.ewp</path>
  </project>
  <batchBuild/>
</workspace>


