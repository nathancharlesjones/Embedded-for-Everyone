# Keil uVision project vadc_measurement_xmc13.uvprojx, settings and files
target vadc_measurement_xmc13 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC1302-T038x0200 Infineon
  pack: Infineon.XMC1000_DFP.2.9.0
  cpu: IROM(0x10001000,0x32000) IRAM(0x20000000,0x3FFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: vadc_measurement_xmc13
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x10001000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group Source
    ../: main.c
  group Doc
    ../: Readme.txt
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:XMClib:GPIO 1.0.0, Device:XMClib:SCU 1.0.0, Device:XMClib:VADC 1.0.0
