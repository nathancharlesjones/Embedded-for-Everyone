<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\flash_program_xmc13.ewp</path>
  </project>
  <batchBuild/>
</workspace>


