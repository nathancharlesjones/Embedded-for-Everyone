# IAR project uart_shell_xmc13.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: XMC1302-T038x0200 Infineon XMC1302-T038x0200
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: XMC1302_T038x0200
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\XMClib\inc; ..\..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\..\CMSIS\Infineon\XMC1300_series\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: uart_shell_xmc13.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c retarget_io.c ring_buffer.c serial.c shell.c
  group Libraries/CMSIS
    ../../../../../../CMSIS/Infineon/XMC1300_series/Source/IAR/: startup_XMC1300.s
    ../../../../../../CMSIS/Infineon/XMC1300_series/Source/: system_XMC1300.c
  group Libraries/XMClib
    ../../../../../src/: xmc1_eru.c xmc1_flash.c xmc1_gpio.c xmc1_rtc.c xmc1_scu.c xmc_acmp.c xmc_bccu.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_eru.c xmc_gpio.c xmc_i2c.c xmc_ledts.c xmc_math.c xmc_posif.c xmc_prng.c xmc_rtc.c xmc_spi.c xmc_uart.c xmc_usic.c xmc_vadc.c xmc_wdt.c
