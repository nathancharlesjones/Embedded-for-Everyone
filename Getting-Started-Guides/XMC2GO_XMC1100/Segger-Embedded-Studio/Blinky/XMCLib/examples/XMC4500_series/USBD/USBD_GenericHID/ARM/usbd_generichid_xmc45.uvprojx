# Keil uVision project usbd_generichid_xmc45.uvprojx, settings and files
target usbd_generichid_xmc45 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4500-F100x1024 Infineon
  pack: Infineon.XMC4000_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x0C000000,0x100000) IRAM(0x20000000,0xFFC0) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usbd_generichid_xmc45
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ../: Descriptors.c generichid.c main.c
  group USB
    ../USB/Class/Device/: HIDClassDevice.c
    ../USB/Class/Common/: HIDParser.c
    ../USB/Core/: ConfigDescriptors.c Events.c USBTask.c
    ../USB/Core/XMC4000/: Endpoint_XMC4000.c EndpointStream_XMC4000.c USBController_XMC4000.c
  group Docs
    ../: Readme.txt
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:XMClib:GPIO 1.0.0, Device:XMClib:SCU 1.0.0, Device:XMClib:USB 1.0.0
