# Keil uVision project usbd_winusb_xmc45.uvprojx, settings and files
target usbd_winusb_xmc45 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4500-F144x1024 Infineon
  pack: Infineon.XMC4000_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x0C000000,0x100000) IRAM(0x20000000,0xFFC0) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usbd_winusb_xmc45
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ../: Descriptors.c main.c WinUSB.c
  group USB
    ../USB/Core/XMC4000/: Endpoint_XMC4000.c EndpointStream_XMC4000.c USBController_XMC4000.c
    ../USB/Core/: ConfigDescriptors.c Events.c HostStandardReq.c USBTask.c
  group Documentation
    ../: Readme.txt
software components: CMSIS:CORE 4.1.0, Device:Startup , Device:XMClib:GPIO 2.0.0, Device:XMClib:I2C 2.0.0, Device:XMClib:SCU 2.0.0, Device:XMClib:USB 2.0.0, Device:XMClib:VADC 2.0.0
