# Keil uVision project can_transmitter_xmc45.uvprojx, settings and files
target can_transmitter_xmc45 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4500-F144x1024 Infineon
  pack: Infineon.XMC4000_DFP.2.11.0
  cpu: IRAM(0x20000000,0xFFC0) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x0C000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: can_transmitter
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ../: main.c
software components: CMSIS:CORE 5.2.0, Board Support:A/D Converter 1.0.1, Device:Startup 2.2.0, Device:XMClib:CAN 2.1.18, Device:XMClib:GPIO 2.1.18, Device:XMClib:SCU 2.1.18, Device:XMClib:VADC 2.1.18
