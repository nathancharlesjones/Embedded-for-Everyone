# Keil uVision project vadc_measurement_emux_xmc45.uvprojx, settings and files
target vadc_measurement_emux_xmc45 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4500-F144x1024 Infineon
  pack: Infineon.XMC4000_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x0C000000,0x100000) IRAM(0x20000000,0xFFC0) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: vadc_measurement_emux_xmc45
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ../: main.c
  group Doc
    ../: Readme.txt
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:XMClib:GPIO 1.0.0, Device:XMClib:SCU 1.0.0, Device:XMClib:UART 1.0.0, Device:XMClib:VADC 1.0.0
