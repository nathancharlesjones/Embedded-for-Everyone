# IAR project uart_printf_xmc45.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: XMC4500-F100x1024 Infineon XMC4500-F100x1024
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: XMC4500_F100x1024; XMC_ASSERT_ENABLE; XMC_USER_ASSERT_FUNCTION
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\XMClib\inc; ..\..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\..\CMSIS\Infineon\XMC4500_series\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: uart_printf_xmc45.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c retarget.c
  group Libraries/CMSIS
    ../../../../../../CMSIS/Infineon/XMC4500_series/Source/IAR/: startup_XMC4500.s
    ../../../../../../CMSIS/Infineon/XMC4500_series/Source/: system_XMC4500.c
  group Libraries/XMClib
    ../../../../../src/: xmc4_eru.c xmc4_flash.c xmc4_gpio.c xmc4_rtc.c xmc4_scu.c xmc_can.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_dac.c xmc_dma.c xmc_ebu.c xmc_eru.c xmc_fce.c xmc_gpio.c xmc_hrpwm.c xmc_i2c.c xmc_ledts.c xmc_posif.c xmc_rtc.c xmc_sdmmc.c xmc_spi.c xmc_uart.c xmc_usbd.c xmc_usic.c xmc_vadc.c xmc_wdt.c
