<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\uart_transmit_receive_FIFO_interrupts_xmc45.ewp</path>
  </project>
  <batchBuild/>
</workspace>


