# IAR project httpserver_netconn_xmc45.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: XMC4500-F100x1024 Infineon XMC4500-F100x1024
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: XMC4500_F100x1024; __CORTEX_M4F; __FPU_PRESENT; __CMSIS_RTOS; RELAXKIT; XMC_ETH_PHY_KSZ8081RNB
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\XMClib\inc; ..\..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\..\CMSIS\Infineon\XMC4500_series\Include; ..\..\..\..\..\..\CMSIS\RTOS\RTX\INC; ..\..\..\..\..\..\ThirdPartyLibraries\lwip\src\include; ..\..\..\..\..\..\ThirdPartyLibraries\lwip\src\port\cmsis-rtos\include; ..\..\..\..\..\..\ThirdPartyLibraries\lwip\src\port\cmsis-rtos\netif; ..\httpserver_netconn_xmc45; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AExtraOptionsV2: -j
  OBJCOPY.OOCOutputFile: httpserver_netconn_xmc45.srec
  ILINK.IlinkOutputFile: httpserver_netconn_xmc45.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../../../ThirdPartyLibraries/lwip/src/apps/http/: altcp_proxyconnect.c fs.c http_client.c httpd.c
    ../: ethernetif_init.c main.c
  group cmsis_rtos_rtx
    ../../../../../../CMSIS/RTOS/RTX/SRC/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
    ../../../../../../CMSIS/RTOS/RTX/SRC/IAR/: HAL_CM4.s SVC_Table.s
    ../: RTX_Conf_CM.c
  group Libraries/CMSIS
    ../../../../../../CMSIS/Infineon/XMC4500_series/Source/IAR/: startup_XMC4500.s
    ../../../../../../CMSIS/Infineon/XMC4500_series/Source/: system_XMC4500.c
  group Libraries/XMClib
    ../../../../../src/: xmc4_eru.c xmc4_flash.c xmc4_gpio.c xmc4_rtc.c xmc4_scu.c xmc_can.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_dac.c xmc_dma.c xmc_ebu.c xmc_eru.c xmc_eth_mac.c xmc_eth_phy_dp83848.c xmc_eth_phy_ksz8031rnl.c xmc_eth_phy_ksz8081rnb.c xmc_fce.c xmc_gpio.c xmc_hrpwm.c xmc_i2c.c xmc_ledts.c xmc_posif.c xmc_rtc.c xmc_sdmmc.c xmc_spi.c xmc_uart.c xmc_usbd.c xmc_usic.c xmc_vadc.c xmc_wdt.c
  group lwip/api
    ../../../../../../ThirdPartyLibraries/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/core
    ../../../../../../ThirdPartyLibraries/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/core/ipv4
    ../../../../../../ThirdPartyLibraries/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/core/ipv6
    ../../../../../../ThirdPartyLibraries/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/netif
    ../../../../../../ThirdPartyLibraries/lwip/src/netif/: ethernet.c lowpan6.c slipif.c
  group lwip/netif/ppp
    ../../../../../../ThirdPartyLibraries/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/netif/ppp/polarssl
    ../../../../../../ThirdPartyLibraries/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group lwip/port/cmsis-rtos
    ../../../../../../ThirdPartyLibraries/lwip/src/port/cmsis-rtos/: sys_arch.c
  group lwip/port/cmsis-rtos/netif
    ../../../../../../ThirdPartyLibraries/lwip/src/port/cmsis-rtos/netif/: ethernetif.c
